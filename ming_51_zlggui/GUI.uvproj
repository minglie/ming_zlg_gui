# Keil uVision project GUI.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GUI +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\head;.\src
  group Source Group 1
    ./: STARTUP.A51
    ./src/: ConvertColor.c delay.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c main.c menu.c spline.c windows.c
  group head
    ./head/: AT89X52.h config.h ConvertColor.h delay.h FONT_MACRO.H font5_7.h FONT8_8.H FONT24_32.H GUI_BASIC.H GUI_CONFIG.H GUI_StockC.h lcmdrv.h Loadbit.h menu.h spline.h windows.h
